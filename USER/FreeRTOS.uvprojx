# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Rover X +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\HEAD;..\HARDWARE\FreeRTOSDef;..\HARDWARE\I_O;..\CANOPEN\CANCAN;..\CANOPEN\CANTIMER;..\CANOPEN\inc;..\CANOPEN\src;..\CANOPEN;..\HARDWARE\Motor;..\HARDWARE\ETHERNET;..\FWLIB\STM32F4x7_ETH_Driver\src;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\udp_demo;..\MALLOC;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\HARDWARE\24CXX;..\HARDWARE\BranchPath;..\HARDWARE\IOI2C;..\HARDWARE\myiic;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\TIMER1;..\HARDWARE\USART3;..\AGV_Logic\AGV_contr;..\AGV_Logic\BranchPath;..\AGV_Logic\East_nor;..\AGV_Logic\GPS;..\AGV_Logic\magnetic;..\AGV_Logic\MAP;..\AGV_Logic\PID;..\AGV_Logic\RFID;..\AGV_Logic\StationCardNum;..\AGV_Logic\stmflash;..\AGV_Logic\ULTRASONIC;..\AGV_Logic\vehicle_key;..\HARDWARE\PWM;..\DaCai\cmd_process;..\DaCai\cmd_queue;..\DaCai\HMI_cmd;..\DaCai\HMI_DRIVE;..\HARDWARE\RAD;..\HARDWARE\USART4;..\HARDWARE\usart6;..\HARDWARE\Vehicle;..\HARDWARE\USART2;..\HARDWARE\MPU9250;..\DMP;..\HARDWARE\USART4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c main.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/FreeRTOSDef/: FreeRTOSDef.c
    ../HARDWARE/HEAD/: HEAD.c
    ../HARDWARE/I_O/: I_O.c
    ../HARDWARE/Motor/: Motor.c Motor.h
    ../HARDWARE/ETHERNET/: lan8720.c lan8720.h
    ../HARDWARE/24CXX/: 24cxx.c 24cxx.h
    ../HARDWARE/myiic/: myiic.c myiic.h
    ../HARDWARE/NRF24L01/: 24l01.c 24l01.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/TIMER1/: timer1.c timer1.h
    ../HARDWARE/USART3/: usart3.c usart3.h
    ../HARDWARE/PWM/: pwm.c pwm.h
    ../HARDWARE/RAD/: RAD.c RAD.h
    ../HARDWARE/USART4/: usart4.c usart4.h
    ../HARDWARE/usart6/: usart6.c usart6.h
    ../HARDWARE/Vehicle/: vehicle.c vehicle.h
    ../HARDWARE/USART2/: usart2.c usart2.h
    ../HARDWARE/MPU9250/: mpu9250.c mpu9250.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group CANOPEN
    ../CANOPEN/: canfestival.c TestMaster.c
    ../CANOPEN/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../CANOPEN/CANCAN/: cancan.c
    ../CANOPEN/CANTIMER/: cantimer.c
  group MALLOC
    ../MALLOC/: malloc.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_APP
    ../LWIP/lwip_app/udp_demo/: udp_demo.c udp_demo.h
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c lwip_comm.h
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c sys_arch.h
  group AGV_Logic
    ../AGV_Logic/AGV_contr/: AGV_contr.c AGV_contr.h
    ../AGV_Logic/BranchPath/: BranchPath.c BranchPath.h
    ../AGV_Logic/East_nor/: East_nor.c East_nor.h
    ../AGV_Logic/GPS/: gps.h gps.c
    ../AGV_Logic/magnetic/: magnetic.c magnetic.h
    ../AGV_Logic/MAP/: map.c map.h
    ../AGV_Logic/PID/: pid.c pid.h
    ../AGV_Logic/RFID/: RFID.c RFID.h
    ../AGV_Logic/StationCardNum/: StationCardNum.c StationCardNum.h
    ../AGV_Logic/stmflash/: stmflash.c stmflash.h
    ../AGV_Logic/ULTRASONIC/: ultrasonic.c ultrasonic.h
    ../AGV_Logic/vehicle_key/: vehicle_key.h vehicle_key.c
  group DaCai
    ../DaCai/cmd_process/: cmd_process.h
    ../DaCai/cmd_queue/: cmd_queue.c cmd_queue.h
    ../DaCai/HMI_cmd/: HMI_cmd.c HMI_cmd.h
    ../DaCai/HMI_DRIVE/: hmi_driver.c hmi_driver.h
